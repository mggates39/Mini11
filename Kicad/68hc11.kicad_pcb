# Repository mggates39/Mini11

## KiCad design Kicad/68hc11.kicad_pcb

Parts:
C1: 10uF; CP_Radial_D5.0mm_P2.00mm
C2, C3, C4, C5, C6, C10: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C7, C8: 22pF; C_Disc_D3.0mm_W1.6mm_P2.50mm
C9: 0.1uF; C_Disc_D3.0mm_W2.0mm_P2.50mm
J2: Conn_01x03; PinHeader_1x03_P2.54mm_Horizontal
J3: Conn_01x09; PinHeader_1x09_P2.54mm_Vertical
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J5: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
J6: Conn_01x06; PinHeader_1x06_P2.54mm_Horizontal
JP1: MODA; PinHeader_1x02_P2.54mm_Vertical
JP2: MODB; PinHeader_1x02_P2.54mm_Vertical
JP3: Jumper_3_Open; PinHeader_1x03_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8: 10K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R10: 10M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
U1: 68HC11A8; DIP-48_W15.24mm
U2: AS6C4008; DIP-32_W15.24mm
U3: 74HCT573; DIP-20_W7.62mm
U4: 74HCT139; DIP-16_W7.62mm
U5: 27C256; DIP-28_W15.24mm
U6: DS1233; TO-92_Inline_Narrow_Oval
U7: 74HCT00; DIP-14_W7.62mm
Y1: 8MHz; Crystal_HC49-U_Vertical

Connections:
A0: U2.12 (A0), U3.12 (Q7), U5.10 (A0)
A1: U2.11 (A1), U3.13 (Q6), U5.9 (A1)
A2: U2.10 (A2), U3.14 (Q5), U5.8 (A2)
A3: U2.9 (A3), U3.15 (Q4), U5.7 (A3)
A4: U2.8 (A4), U3.16 (Q3), U5.6 (A4)
A5: U2.7 (A5), U3.17 (Q2), U5.5 (A5)
A6: U2.6 (A6), U3.18 (Q1), U5.4 (A6)
A7: U2.5 (A7), U3.19 (Q0), U5.3 (A7)
A8: U1.16 (A8/PB0), U2.27 (A8), U5.25 (A8)
A9: U1.15 (PB1), U2.26 (A9), U5.24 (A9)
A10: U1.14 (PB2), U2.23 (A10), U5.21 (A10)
A11: U1.13 (PB3), U2.25 (A11), U5.23 (A11)
A12: U1.12 (PB4), U2.4 (A12), U5.2 (A12)
A13: U1.11 (PB5), U2.28 (A13), U5.26 (A13)
A14: U1.10 (PB6), U2.3 (A14), U4.2 (A0)
A15: U1.9 (A15/PB7), U2.31 (A15), U4.3 (A1)
A16: U1.4 (OC4/PA4), U2.2 (A16)
A17: U1.3 (OC3/PA5), U2.30 (A17)
A18: U1.2 (OC2/PA6), U2.1 (A18)
AD0: U1.31 (AD0/PC0), U2.15 (D2), U3.9 (D7), U5.13 (D2)
AD1: U1.32 (PC1), U2.14 (D1), U3.8 (D6), U5.12 (D1)
AD2: U1.33 (PC2), U2.13 (D0), U3.7 (D5), U5.11 (D0)
AD3: U1.34 (PC3), U2.17 (D3), U3.6 (D4), U5.15 (D3)
AD4: U1.35 (PC4), U2.18 (D4), U3.5 (D3), U5.16 (D4)
AD5: U1.36 (PC5), U2.19 (D5), U3.4 (D2), U5.17 (D5)
AD6: U1.37 (PC6), U2.20 (D6), U3.3 (D1), U5.18 (D6)
AD7: U1.38 (AD7/PC7), U2.21 (D7), U3.2 (D0), U5.19 (D7)
AS: U1.26 (AS), U3.11 (Load)
CS: J3.6, U1.47 (PD5/SS-)
CS1: J3.7, U1.1 (PAI/PA7)
E: U1.27 (E), U7.1, U7.2
EXTAL: C7.1, R10.1, U1.29 (EXTAL), Y1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, J2.3, J3.1, J4.1, J4.3, J5.5, J6.1, JP1.2, JP2.2, JP3.1 (A), U1.21 (VRL), U1.23 (GND), U2.16 (GND), U2.22 (CE), U3.1 (OE), U3.10 (GND), U4.8 (GND), U5.14 (GND), U5.20 (~CE), U6.1 (Gnd), U7.4, U7.5, U7.7 (GND), U7.9, U7.10, U7.12, U7.13
IRQ: J3.8, R3.2, U1.41 (IRQ)
MISO: J3.3, U1.44 (PD2/MISO)
MODA: JP1.1, R1.2, U1.25 (MODA)
MODB: JP2.1, R2.2, U1.24 (MODB)
MOSI: J3.4, U1.45 (PD3/MOSI)
unnamed: J6.2, U1.20 (PE3)
unnamed: J6.3, U1.19 (PE2)
unnamed: J6.4, U1.18 (PE1)
unnamed: J6.5, U1.17 (PE0)
unnamed: JP3.2 (C), U5.27 (A14)
unnamed: U4.7 (O3), U4.13 (A1)
unnamed: U4.15 (E), U7.3
PA0: J5.2, R6.2, U1.8 (IC3/PA0)
PA1: J5.3, R7.2, U1.7 (IC2/PA1)
PA2: J5.4, R8.2, U1.6 (IC1/PA2)
RAMOE: U2.24 (OE), U4.9 (O3)
RAMWR: U2.29 (WE), U4.10 (O2)
RESET: J3.9, U1.39 (RESET), U6.2 (RESET)
ROMEN: U1.5 (OC5/PA3), U4.1 (E)
ROMOE: U4.11 (O1), U5.22 (~OE)
RW: U1.28 (R/W), U4.14 (A0)
RX: J2.1, U1.42 (PD0/RX)
SCLK: J3.5, U1.46 (PD4/SCLK)
TX: J2.2, R5.2, U1.43 (PD1/TX)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C9.1, C10.1, J3.2, J4.2, J5.1, J6.6, JP3.3 (B), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, U1.48 (VCC), U2.32 (VCC), U3.20 (VCC), U4.16 (VCC), U5.1 (VPP), U5.28 (VCC), U6.3 (Vcc), U7.14 (VCC)
VRH: C6.1, R9.2, U1.22 (VRH)
XIRQ: R4.2, U1.40 (XIRQ)
XTAL: C8.1, R10.2, U1.30 (XTAL), Y1.1

Notes on the sheet:
FIXME: need to swap ROMEN and A16 as PA3 is not determinate at boot whilst PA4/5/6 are low (Q: do we - manual says PA3-PA6 start as 0)
Add a proper power plug (USB to through hole ?)

Board: 2 copper layers, 86.0 x 88.3 mm, 36 parts (0 on the bottom side), 61 nets.

## Commit log

2023-03-09 Updated to KiCad 6.0
    Added new 3d models among other settings
2023-03-09 Added KiCad .gitignore settings

Notices in the files:
Kicad/68hc11.kicad_pcb:
(C) 2019 Etched Pixels
